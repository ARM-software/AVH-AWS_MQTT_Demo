# Keil uVision project AWS_MQTT_MutualAuth.uvprojx, settings and files
target VHT_MPS2_Cortex-M7 (6160000::V6.16::ARMCLANG)
  device: CMSDK_CM7_DP_VHT ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: configENABLED_NETWORKS=AWSIOT_NETWORK_TYPE_ETH
  c include: .\Board\VHT_MPS2_Cortex-M7
  asm include: .
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\RTE\Device\CMSDK_CM7_DP_VHT\ac6_arm.sct
  group App
    ./: app_main.c
    ./Board/IMXRT1050-EVKB/: network_startup.c
    ./Board/VHT_MPS2_Cortex-M7/: socket_startup.c
  group Documentation
    ./: README.md
  group demos_common_pkcs11_helpers
    ./amazon-freertos/demos/common/pkcs11_helpers/: pkcs11_helpers.c pkcs11_helpers.h
  group demos_coreMQTT
    ./amazon-freertos/demos/coreMQTT/: mqtt_demo_mutual_auth.c
  group demos_demo_runner
    ./amazon-freertos/demos/demo_runner/: aws_demo.c iot_demo_freertos.c iot_demo_runner.c
  group demos_include
    ./amazon-freertos/demos/include/: aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_iot_metrics.h iot_config_common.h iot_demo_logging.h iot_demo_runner.h
  group demos_network_manager
    ./amazon-freertos/demos/network_manager/: aws_iot_network_manager.c iot_network_manager_private.h
  group libraries_abstractions_platform_freertos
    ./amazon-freertos/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_threads_freertos.c
    ./amazon-freertos/libraries/abstractions/platform/freertos/include/platform/: iot_platform_types_freertos.h
  group libraries_abstractions_platform_include
    ./amazon-freertos/libraries/abstractions/platform/include/platform/: iot_clock.h iot_network.h iot_threads.h
    ./amazon-freertos/libraries/abstractions/platform/include/types/: iot_network_types.h iot_platform_types.h
  group libraries_abstractions_secure_sockets
    ./amazon-freertos/libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h
  group libraries_abstractions_transport_secure_sockets
    ./amazon-freertos/libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c transport_secure_sockets.h
  group libraries_abstractions_wifi
    ./amazon-freertos/libraries/abstractions/wifi/include/: iot_wifi.h
  group libraries_c_sdk_standard_common
    ./amazon-freertos/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group libraries_c_sdk_standard_common_include
    ./amazon-freertos/libraries/c_sdk/standard/common/include/: iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_taskpool.h
    ./amazon-freertos/libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
    ./amazon-freertos/libraries/c_sdk/standard/common/include/types/: iot_taskpool_types.h
  group libraries_c_sdk_standard_common_taskpool
    ./amazon-freertos/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries_logging
    ./amazon-freertos/libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
    ./amazon-freertos/libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group libraries_freertos_plus_standard_crypto
    ./amazon-freertos/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
    ./amazon-freertos/libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries_freertos_plus_standard_tls
    ./amazon-freertos/libraries/freertos_plus/standard/tls/src/: iot_tls.c
    ./amazon-freertos/libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group config_files
    ./config_files/: aws_demo_config.h aws_mbedtls_config.h core_mqtt_config.h core_pkcs11_config.h iot_config.h mqtt_demo_mutual_auth_config.h aws_iot_network_config.h aws_wifi_config.h FreeRTOSIPConfig.h iot_secure_sockets_config.h
  group interfaces
    ./Interfaces/: core_pkcs11_pal.c threading_alt.h iot_socket.h
    ./Interfaces/IoT_Socket/: iot_secure_sockets.c
    ./Interfaces/WiFi/: iot_secure_sockets.c iot_wifi.c
    ./Interfaces/VSocket/: iot_socket.c arm_vsocket.h
  group Board
    ./Board/VHT_MPS2_Cortex-M7/: main.c main.h
    ./Board/IMXRT1050-EVKB/: main.c main.h
  group Board IO
    ./Board/VHT_MPS2_Cortex-M7/: retarget_stdio.c
    ./Board/IMXRT1050-EVKB/: retarget_stdio.c
  group MCUXpresso
    ./: IMXRT1050-EVKB.mex
target IMXRT1050-EVKB ESP8266 (6160000::V6.16::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.13.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: configENABLED_NETWORKS=AWSIOT_NETWORK_TYPE_WIFI SDK_I2C_BASED_COMPONENT_USED SKIP_SYSCLK_INIT XIP_BOOT_HEADER_DCD_ENABLE=1 XIP_BOOT_HEADER_ENABLE=1 XIP_EXTERNAL_FLASH=1
  c include: .\Board\IMXRT1050-EVKB
  asm define: SDK_I2C_BASED_COMPONENT_USED SKIP_SYSCLK_INIT XIP_BOOT_HEADER_DCD_ENABLE=1 XIP_BOOT_HEADER_ENABLE=1 XIP_EXTERNAL_FLASH=1
  asm include: .
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ./RTE/Device/MIMXRT1052DVL6B/MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --summary_stderr --info summarysizes --load_addr_map_info --entry=Reset_Handler
software components: RTOS:Config 10.4.3, RTOS:Core 10.4.3, RTOS:Event Groups 10.4.3, RTOS:Heap 10.4.3, RTOS:Stream Buffer 10.4.3, RTOS:Timers 10.4.3, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.4.3, Security:mbed TLS 2.24.0, FreeRTOS:backoffAlgorithm 1.0.0, FreeRTOS:coreMQTT Agent 1.0.1, FreeRTOS:coreMQTT 1.1.0, FreeRTOS:corePKCS11 3.0.0, Security:PKCS11 3.0.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Common 2.0.0, CMSIS Driver:Ethernet MAC 1.2.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.3.0, CMSIS Driver:USART 1.0.3, CMSIS Driver:VIO:Board 1.0.1, CMSIS Driver:WiFi:ESP8266 1.4.0, Device:Startup 1.1.0, Board Support:SDK Drivers:evkbimxrt1050 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis 2.2.0, Device:CMSIS:MIMXRT1052_header 1.0.0, Device:CMSIS:MIMXRT1052_system 1.0.0, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:common 2.3.0, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:edma 2.4.2, Device:SDK Drivers:enet 2.5.0, Device:SDK Drivers:fxos8700cq 1.0.0, Device:SDK Drivers:gpio 2.0.5, Device:SDK Drivers:i2c 2.3.0, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.5.1, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.5.0, Device:SDK Drivers:nic301 2.0.0, Device:SDK Drivers:sdhc 2.8.0, Device:SDK Drivers:xip_device 2.0.2, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
